# Keil uVision project moban.uvprojx, settings and files
target moban (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: moban +hex
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\stm32f103\libraries;.\stm32f103\startup;.\system;.\user;.\user\no_system_user;.\user\FreeRTOS_user;.\app;.\FreeRTOS_App;.\FreeRTOS_App\FreeRTOS_lib;.\FreeRTOS_App\FreeRTOS_Sys;.\app\fatfs;.\app\myfatfs;.\app\MPU6050_DMP;.\app\pinyinshuru;.\app\picture;.\app\USB\usb_device;.\app\USB\usb_upan
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group set
    ./user/: set.h no_system_set.h
  group user
    ./user/: no_system_main.c
  group system
    ./system/: stm32f10x_it.c sys.c usart1.c usart2.c usart3.c
  group startup
    ./stm32f103/startup/: system_stm32f10x.c startup_stm32f10x_md.s core_cm3.c
  group libraries
    ./stm32f103/libraries/: misc.c stm32f10x_bkp.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_usart.c
software components: CMSIS:CORE 5.0.1
